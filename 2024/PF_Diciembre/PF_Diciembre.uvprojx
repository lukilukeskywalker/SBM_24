# Keil uVision project PF_Diciembre.uvprojx, settings and files
target STM32F429_Nucleo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PF_Diciembre +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group principal
    ./principal/: principal.c principal.h
  group hora
    ./Clock/: clock.c clock.h
  group LCD
    ./LCD/: Arial12x12.h lcd.c lcd.h
  group leds_nucleo
    ./leds_nucleo/: leds_nucleo.c leds_nucleo.h
  group joystick
    ./Joystick/: joystick.c joystick.h
  group main
    ./: main.c main.h
  group utils
    ./: stm_err.h stm_log.c stm_log.h circ_buf.c circ_buf.h
  group accel&temp
    ./Acelerometro/: accel&temp.c accel&temp.h
    ./Acelerometro/libs/adxl34x/: adxl34x.c adxl34x.h
  group com
    ./COM/: com.c com.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS Driver:I2C 2.12, CMSIS Driver:SPI 2.18, CMSIS Driver:USART 2.16, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
