# Keil uVision project PF_Julio.uvprojx, settings and files
target NUCLEO_F429 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PF_Julio24 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group com
    ./COM/: com.c com.h
  group Principal
    ./: main.c main.h PF_conf.h principal.c principal.h circ_buf.h circ_buf.c
  group led_control
    ./led_control/: led_control.c led_control.h
  group pot
    ./pot/: pot.c pot.h
  group lum
    ./lum/: lum.h lum.c bh1750.c bh1750.h
  group hora
    ./hora/: clock.c clock.h
  group lcd
    ./LCD/: Arial12x12.h lcd.c lcd.h
  group joystick
    ./Joystick/: joystick.c joystick.h
  group stm_utils
    ./: stm_err.h stm_log.c stm_log.h
  group pwm
    ./pwm/: pwm.c pwm.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS Driver:I2C 2.12, CMSIS Driver:SPI 2.18, CMSIS Driver:USART 2.16, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
